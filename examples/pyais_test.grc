options:
  parameters:
    author: muaddib
    generate_options: no_gui
    id: pyais_test
    output_language: python
    title: Test application for gr-PyAIS JSON Parser
  states: {}

blocks:
- name: NMEA
  id: variable
  parameters:
    value: '"!AIVDM,1,1,,B,177KQJ5000G?tO`K>RA1wUbN0TKH,0*5C"'
  states: {}
- name: NMEA_bytes
  id: variable
  parameters:
    value: '[ord(i) for i in NMEA]'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: ' pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(len(NMEA_bytes),(NMEA_bytes)))'
    period: '1000'
  states: {}
- name: pyais_parser_pyais_json_1
  id: pyais_parser_pyais_json
  parameters:
    console_output: 'True'
    filename: /tmp/ais_log2.json
    logtofile: 'True'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pyais_parser_pyais_json_1, nmea_in]

metadata:
  file_format: 1
  grc_version: v3.10.9.2-8-g2faa48e5
